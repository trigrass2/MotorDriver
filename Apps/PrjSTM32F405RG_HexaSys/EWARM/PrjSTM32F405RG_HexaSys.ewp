# IAR project PrjSTM32F405RG_HexaSys.ewp, settings and files
configuration PrjSTM32F405RG_HexaSys (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F405xx; ARM_MATH_CM4; STM32F405RG_HEXASYS; __FPU_PRESENT; HEXA_BD_10A_V20
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\..\..\ServoMotor; ..\..\..\Common; ..\..\..\CANOpen
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: PrjSTM32F405RG_HexaSys.bin
  ILINK.IlinkOutputFile: PrjSTM32F405RG_HexaSys.out
  ILINK.IlinkIcfFile: stm32f405xx_flash.icf
  ILINK.IlinkAdditionalLibs: $TOOLKIT_DIR$\CMSIS\Lib\IAR\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/CANopen
    ../../../CANOpen/: CanDef.h CanOpen.cpp CanOpen.h CanOpenCia301.cpp CanOpenCia301.h CanOpenCia301Def.h CanOpenCia402.cpp CanOpenCia402.h CanOpenCia402ConfigParameter.cpp CanOpenCia402Def.h CanOpenCia402Kitech.cpp CanOpenCia402Kitech.h CanOpenCia402KitechDef.h CanOpenDef.h CanOpenInterface.cpp CanOpenInterface.h
  group Application/Common
    ../../../Common/: binary_values_bit.h can_comm.c can_comm.h math_def.h matrix.c matrix.h MovingAverage.cpp MovingAverage.h queue.c queue.h utils.h
  group Application/EWARM
    ./: startup_stm32f405xx.s
  group Application/ServoMotor
    ../../../ServoMotor/: CurrentController.cpp CurrentController.h FieldOrientedControl.c FieldOrientedControl.h Io.h KalmanFilter.cpp KalmanFilter.h MotorProperties.c MotorProperties.h MotorProperty.cpp MotorProperty.h online_mechanic_param.cpp online_mechanic_param.h Peripheral.h PidController.cpp PidController.h PositionController.cpp PositionController.h PositionDiff.h Pwm.h SCurveProfile.h ServoController.cpp ServoController.h ServoControllerInterface.cpp ServoControllerInterface.h TrapezoidalProfile.h VelocityController.cpp VelocityController.h
  group Application/User
    ../Src/: adc.c can.c dma.c gpio.c Io.c main.c pwm.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
