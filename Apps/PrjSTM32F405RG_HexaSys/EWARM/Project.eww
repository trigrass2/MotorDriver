<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PrjSTM32F405RG_HexaSys.ewp</path>
  </project>
  <batchBuild />
</workspace>
