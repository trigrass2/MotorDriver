# IAR project MotorDrv.ewp, settings and files
configuration MotorDrv (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743VI ST STM32H743VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx; ARM_MATH_CM4; STM32F405RG_HEXASYS; __FPU_PRESENT; HEXA_BD_10A_V20
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../ServoMotor; ../Common; ../CANOpen
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: MotorDrv.hex
  ILINK.IlinkOutputFile: MotorDrv.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkAdditionalLibs: $TOOLKIT_DIR$\CMSIS\Lib\IAR\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/CANOpen
    ../CANOpen/: CanDef.h CanOpen.cpp CanOpen.h CanOpenCia301.cpp CanOpenCia301.h CanOpenCia301Def.h CanOpenCia402.cpp CanOpenCia402.h CanOpenCia402ConfigParameter.cpp CanOpenCia402Def.h CanOpenCia402Kitech.cpp CanOpenCia402KitechDef.h CanOpenDef.h CanOpenInterface.cpp CanOpenInterface.h
  group Application/Common
    ../Common/: can_comm.c matrix.c MovingAverage.cpp queue.c
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/ServoMotor
    ../ServoMotor/: CurrentController.cpp FieldOrientedControl.c KalmanFilter.cpp MotorProperties.c MotorProperty.cpp online_mechanic_param.cpp PidController.cpp PositionController.cpp ServoController.cpp ServoControllerInterface.cpp VelocityController.cpp VoltageController.cpp
  group Application/User
    ../Src/: Io.c pwm.c utils.c main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c
